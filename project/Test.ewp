# IAR project Test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052C6 STM8L052C6
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\Test\ARM\STM8L\STM8L152C6\test0404\lib\inc; E:\Test\ARM\STM8L\STM8L152C6\test0404\lib\src; E:\Test\ARM\STM8L\STM8L152C6\test0404\lcd; E:\Test\ARM\STM8L\STM8L152C6\test0404\rs485; E:\Test\ARM\STM8L\STM8L152C6\test0404\user; E:\Test\ARM\STM8L\STM8L152C6\test0404\pwm
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Test.hex
  ILINK.IlinkOutputFile: Test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group lib
    ../lib/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group mylib
    ../lcd/: lcd.c
    ../rs485/: rs485.c
  group user
    ../user/: main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
